<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\example_mti1_i2c_spi_mtssp_protocol_explorer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


